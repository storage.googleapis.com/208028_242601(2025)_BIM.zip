Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: e894146a-4833-4a84-92aa-b003607abd5d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 242601(2025).ifc
Time: 2025-05-20T22:49:21
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum
Other(Type) - Category: Levels; Family Name: Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcFlowController: 242601(2025):242601 Hand shower, 242601(2025):242601 Hand shower:358896
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - General - Author: BIMStone; BIMObjectName: 242601(2025); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower heads; NBSReference: 45-35-70/333; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_76; Uniclass2015Description: Shower heads; Uniclass2015Reference: Pr_40_20_87_76; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EN Standard: EN 1112; ETIM Class Number: EC010161 Hand shower; Noise Class: I (ISO 3822); URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/242601; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/242601
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Connection Size: G1/2; Flow Rate At 300kPa: 0.2 dm3/s; Hand Shower Size: Ø 90 mm; Max. Hot Water Supply: 65 C; Shower Parts: Anti limescale technology (easy to clean); Shower Spray: Refreshing - Strong water stream, activates and refreshes body; Shower Spray Number: 1 spray function; Surface treatment: Chrome; Working Pressure: 50 - 500 kPa
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 56.5246 mm; NominalHeight: 217.441 mm; NominalWidth: 90 mm
Type - Identity Data - 3D View: https://static.oras.com/3D/242601; Catalog Drawing URL: http://static.oras.com/catdrw/242601; Category B2B: Accessories; Category B2C: Shower solutions; Dimension Drawing URL: http://static.oras.com/dimdrw/242601; FDV Document URL: http://www.oras.com/datasheet/242601/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/242601; Group: Hand shower; Installation and Maintenance Guide URL: http://static.oras.com/manual/242601; Interactive AR View URL: https://static.oras.com/AR/242601; Long Marketing: Introducing the Oras Linea hand shower, the perfect addition to any shower solution. With its sleek chrome surface treatment and anti-limescale technology, this hand shower is easy to clean and maintain. The refreshing spray type provides a strong water stream that activates and refreshes the body. This new product emphasizes quality and at the same time offers outstanding price-performance. Choose the Linea line for daily enjoyment in everyday use.; Manufacturer: Oras; Market: International;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/242601; Model: 242601 Hand shower; Name_en: 242601 Hand shower; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 242601; Product Family: Oras Linea; Product Image URL: http://static.oras.com/image/242601; Product URL: http://static.oras.com/242601; Technical DataSheet URL: http://www.oras.com/datasheet/242601/en; Type Name: 242601 Hand shower; Warranty Information URL: http://warranty.oras.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 242601(2025); Features: n/a; Finish: Polished; Grade: n/a; Material: Composite; ModelNumber: n/a; ModelReference: 242601; Name: 242601 Hand shower; ReplacementCost: n/a; Shape: Sculptured; Size: 90x55x220 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Material: <Unnamed>
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 0; Level: Level 0; Moves With Nearby Elements: no; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Area: 0.0369477 m2; Volume: 0.00110617 m3
Identity Data - Mark: 17
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 242601(2025); Family and Type: 242601(2025): 242601 Hand shower; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 242601 Hand shower; Type Id: 358880; WarrantyStartDate: n/a
